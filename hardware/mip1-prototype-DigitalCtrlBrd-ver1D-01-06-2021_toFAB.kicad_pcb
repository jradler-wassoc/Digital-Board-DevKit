# Repository jradler-wassoc/Digital-Board-DevKit (continued)

## KiCad design hardware/mip1-prototype-DigitalCtrlBrd-ver1D-01-06-2021_toFAB.kicad_pcb (continued)

Board: 4 copper layers, 255.3 x 182.4 mm, 115 parts (0 on the bottom side), 125 nets.

## Commit log

2021-07-07 Added only the digital components of the device in order to quickly engineer a devkit for device firmware.
