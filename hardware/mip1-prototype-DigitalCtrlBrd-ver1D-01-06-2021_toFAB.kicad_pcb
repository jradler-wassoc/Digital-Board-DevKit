# Repository jradler-wassoc/Digital-Board-DevKit

## KiCad design hardware/mip1-prototype-DigitalCtrlBrd-ver1D-01-06-2021_toFAB.kicad_pcb

Parts:
C2001: 0.33uF / 865230640003; C_Elec_4x5.4
C2002: 0.1uF; C_0402_1005Metric
H2001, H2002, H2003, H2004: MountingHole; MountingHole_3.2mm_M3_Pad_Via
J2001, J2002, J2003, J2004, J2005, J2006, J2007: Conn_01x12_Male; PinHeader_1x12_P1.27mm_Vertical
J2008: PinHeader_1x20_P2.54mm_Vertical
J2009: Conn_02x03_Odd_Even; Molex_Micro-Fit_3.0_43045-0615_2x03_P3.00mm_Vertical
R2001, R2002, R2003, R2004, R2005, R2006, R2007, R2008, R2009, R2010, R2011, R2012, R2013, R2014, R2015, R2016, R2017: 1k; R_0402_1005Metric

Connections:
+5V_MAINS: C2001.1, C2002.1, J2001.1, J2002.1, J2003.1, J2004.1, J2005.1, J2006.1, J2007.1, J2009.1, J2009.3, J2009.5; also elsewhere on the board
/digital_control_board/C1_EF: R2005.2; also elsewhere on the board
/digital_control_board/C2_EF: R2006.2; also elsewhere on the board
/digital_control_board/C3_EF: R2003.2; also elsewhere on the board
/digital_control_board/C4_EF: R2001.2; also elsewhere on the board
/digital_control_board/C5_EF: R2011.2; also elsewhere on the board
/digital_control_board/C6_EF: R2013.2; also elsewhere on the board
/digital_control_board/C7_EF: R2009.2; also elsewhere on the board
/digital_control_board/SER0: J2002.4; also elsewhere on the board
/digital_control_board/SER1: J2003.4; also elsewhere on the board
/digital_control_board/SER2: J2004.4; also elsewhere on the board
/digital_control_board/SER3: J2001.4; also elsewhere on the board
/digital_control_board/SER4: J2005.4; also elsewhere on the board
/digital_control_board/SER5: J2006.4; also elsewhere on the board
/digital_control_board/SER6: J2007.4; also elsewhere on the board
/digital_control_board/sheet63FDD82A/MISO: R2017.1; also elsewhere on the board
/digital_control_board/sheet63FDD82A/MOSI: R2016.1; also elsewhere on the board
/digital_control_board/sheet63FDD82A/SCLK: R2015.1; also elsewhere on the board
/digital_control_board/~C1_CS_ADC: R2008.2; also elsewhere on the board
/digital_control_board/~C2_CS_ADC: R2007.2; also elsewhere on the board
/digital_control_board/~C3_CS_ADC: R2004.2; also elsewhere on the board
/digital_control_board/~C4_CS_ADC: R2002.2; also elsewhere on the board
/digital_control_board/~C5_CS_ADC: R2012.2; also elsewhere on the board
/digital_control_board/~C6_CS_ADC: R2014.2; also elsewhere on the board
/digital_control_board/~C7_CS_ADC: R2010.2; also elsewhere on the board
CTR: J2008.18; also elsewhere on the board
DIO0: J2008.1; also elsewhere on the board
DIO1: J2008.3; also elsewhere on the board
DIO2: J2008.5; also elsewhere on the board
DIO3: J2008.7; also elsewhere on the board
DIO4: J2008.9; also elsewhere on the board
DIO5: J2008.11; also elsewhere on the board
DIO6: J2008.13; also elsewhere on the board
DIO7: J2008.15; also elsewhere on the board
unnamed: J2001.2, R2001.1
unnamed: J2001.3, R2002.1
unnamed: J2002.2, R2005.1
unnamed: J2002.3, R2008.1
unnamed: J2003.2, R2006.1
unnamed: J2003.3, R2007.1
unnamed: J2004.2, R2003.1
unnamed: J2004.3, R2004.1
unnamed: J2005.2, R2011.1
unnamed: J2005.3, R2012.1
unnamed: J2006.2, R2013.1
unnamed: J2006.3, R2014.1
unnamed: J2007.2, R2009.1
unnamed: J2007.3, R2010.1
PCOM: C2001.2, C2002.2, J2001.12, J2002.12, J2003.12, J2004.12, J2005.12, J2006.12, J2007.12, J2008.2, J2008.4, J2008.6, J2008.8, J2008.10, J2008.12, J2008.14, J2008.20, J2009.2, J2009.4, J2009.6; also elsewhere on the board
RCLK: J2001.8, J2002.8, J2003.8, J2004.8, J2005.8, J2006.8, J2007.8; also elsewhere on the board
RX_MISO: J2001.11, J2002.11, J2003.11, J2004.11, J2005.11, J2006.11, J2007.11, R2017.2
RX_MOSI: J2001.10, J2002.10, J2003.10, J2004.10, J2005.10, J2006.10, J2007.10, R2016.2
RX_SCLK: J2001.9, J2002.9, J2003.9, J2004.9, J2005.9, J2006.9, J2007.9, R2015.2
SRCLK: J2001.7, J2002.7, J2003.7, J2004.7, J2005.7, J2006.7, J2007.7; also elsewhere on the board
SYNCIO: J2008.16; also elsewhere on the board
TRIG_IN: J2008.17; also elsewhere on the board
~OE: J2001.6, J2002.6, J2003.6, J2004.6, J2005.6, J2006.6, J2007.6; also elsewhere on the board
~SRCLR: J2001.5, J2002.5, J2003.5, J2004.5, J2005.5, J2006.5, J2007.5; also elsewhere on the board

Notes on the sheet:
1.5A, 5VD output
this might not work... it's a linear regulator regulating everything to the same voltage as the input... change to an LDO or ditch it in favor of standard power filtering?

Parts:
C2301, C2305, C2307, C2309: 0.1uF; C_0402_1005Metric
C2302, C2303: 18pF; C_0402_1005Metric
C2304, C2306, C2308: 10uF; C_0402_1005Metric
D2301: AMBER; LED_D5.0mm
D2302: RED; LED_D5.0mm
D2303: GREEN; LED_D5.0mm
FB2301: Ferrite_Bead_Small; L_0603_1608Metric
J2301: Conn_01x10; PinSocket_1x10_P2.54mm_Vertical
J2302, J2303: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
J2304: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical
J2305: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J2306: PinHeader_2x05_P2.54mm_Vertical
M2301: ATmega644A-AU; TQFP-44_10x10mm_P0.8mm
R2301: 10k; R_0402_1005Metric
R2302, R2303, R2304, R2305: 330; R_0402_1005Metric
SW2301: EVQQ2; SW_SPST_EVQQ2
Y2301: TXC 20MHz; Crystal_SMD_HC49-SD

Connections:
+5V_MAINS: C2304.1, C2305.1, C2306.2, C2307.1, FB2301.1, J2303.4, J2306.2 (VCC), M2301.5 (VCC), M2301.17 (VCC), M2301.29 (AREF), M2301.38 (VCC), R2301.1; also elsewhere on the board
/digital_control_board/sheet64399DB0/X1: C2303.2, M2301.7 (XTAL2), Y2301.2
/digital_control_board/sheet64399DB0/X2: C2302.2, M2301.8 (XTAL1), Y2301.1
/digital_control_board/sheet64399DB0/~RST: C2301.1, J2306.5 (~RST), M2301.4 (~RESET), R2302.1
CTR: M2301.13 (PD4); also elsewhere on the board
DIO0: M2301.19 (PC0); also elsewhere on the board
DIO1: M2301.20 (PC1); also elsewhere on the board
DIO2: M2301.21 (PC2); also elsewhere on the board
DIO3: M2301.22 (PC3); also elsewhere on the board
DIO4: M2301.23 (PC4); also elsewhere on the board
DIO5: M2301.24 (PC5); also elsewhere on the board
DIO6: M2301.25 (PC6); also elsewhere on the board
DIO7: M2301.26 (PC7); also elsewhere on the board
DISP_MISO: J2301.5, J2305.1, J2306.1 (MOSI), M2301.2 (PB6)
DISP_MOSI: J2301.4, J2305.4, J2306.9 (MISO), M2301.1 (PB5)
DISP_SCK: J2301.6, J2305.3, J2306.7 (SCK), M2301.3 (PB7)
unnamed: C2308.1, C2309.1, FB2301.2, M2301.27 (AVCC)
unnamed: D2301.1 (K), R2303.2
unnamed: D2301.2 (A), M2301.14 (PD5)
unnamed: D2302.1 (K), R2304.2
unnamed: D2302.2 (A), M2301.15 (PD6)
unnamed: D2303.1 (K), R2305.2
unnamed: D2303.2 (A), M2301.16 (PD7)
unnamed: R2301.2, R2302.2, SW2301.1
PCOM: C2301.2, C2302.1, C2303.1, C2304.2, C2305.2, C2306.1, C2307.2, C2308.2, C2309.2, J2301.7, J2303.2, J2303.3, J2305.6, J2306.4 (GND), J2306.6 (GND), J2306.8 (GND), J2306.10 (GND), M2301.6 (GND), M2301.18 (GND), M2301.28 (GND), M2301.39 (GND), R2303.1, R2304.1, R2305.1, SW2301.2; also elsewhere on the board
RXD0: M2301.9 (PD0); also elsewhere on the board
RXD1: M2301.11 (PD2); also elsewhere on the board
SYNCIO: M2301.43 (PB3); also elsewhere on the board
TRIG_IN: M2301.42 (PB2); also elsewhere on the board
TXD0: M2301.10 (PD1); also elsewhere on the board
TXD1: M2301.12 (PD3); also elsewhere on the board
TX_ARM_SWITCH: M2301.32 (PA5); also elsewhere on the board
TX_RUN_SWITCH: M2301.33 (PA4); also elsewhere on the board
~ALRT_INT: M2301.41 (PB1); also elsewhere on the board
~FT801_CS: J2301.3, M2301.37 (PA0)
~FT801_HOST_INT: J2301.2, M2301.35 (PA2)
~FT801_PWR_DN: J2301.1, M2301.36 (PA1)
~SD_CS: J2302.5, M2301.34 (PA3)
~SHDN: M2301.30 (PA7); also elsewhere on the board

Notes on the sheet:
Top-Level UI/System Controller

Parts:
C2201, C2204, C2205, C2206, C2207, C2208: 0.1uF; C_0402_1005Metric
C2202, C2203: 18pF; C_0402_1005Metric
J2201: Conn_02x05; PinHeader_2x05_P2.54mm_Vertical
M2201: ATmega644PA-AU; TQFP-44_10x10mm_P0.8mm
R2201, R2203, R2204: 10k; R_0402_1005Metric
R2202: 330; R_0402_1005Metric
SW2201: EVQQ2; SW_SPST_EVQQ2
U2201: SN74LS165ANSR; SO-16_5.3x10.2mm_P1.27mm
Y2201: TXC 20MHz; Crystal_SMD_HC49-SD

Connections:
+5V_MAINS: C2201.2, C2205.1, C2206.2, C2207.1, C2208.1, J2201.2 (VCC), M2201.5 (VCC), M2201.17 (VCC), M2201.27 (AVCC), M2201.29 (AREF), M2201.38 (VCC), R2201.1, U2201.16 (VCC); also elsewhere on the board
/digital_control_board/C1_EF: U2201.11 (D0); also elsewhere on the board
/digital_control_board/C2_EF: U2201.12 (D1); also elsewhere on the board
/digital_control_board/C3_EF: U2201.13 (D2); also elsewhere on the board
/digital_control_board/C4_EF: U2201.14 (D3); also elsewhere on the board
/digital_control_board/C5_EF: U2201.3 (D4); also elsewhere on the board
/digital_control_board/C6_EF: U2201.4 (D5); also elsewhere on the board
/digital_control_board/C7_EF: U2201.5 (D6); also elsewhere on the board
/digital_control_board/SER0: M2201.23 (PC4); also elsewhere on the board
/digital_control_board/SER1: M2201.25 (PC6); also elsewhere on the board
/digital_control_board/SER2: M2201.41 (PB1); also elsewhere on the board
/digital_control_board/SER3: M2201.43 (PB3); also elsewhere on the board
/digital_control_board/SER4: M2201.19 (PC0); also elsewhere on the board
/digital_control_board/SER5: M2201.21 (PC2); also elsewhere on the board
/digital_control_board/SER6: M2201.14 (PD5); also elsewhere on the board
/digital_control_board/sheet63FDD82A/EF_SERIAL: M2201.34 (PA3), U2201.9 (Q7)
/digital_control_board/sheet63FDD82A/EN_~LD: M2201.40 (PB0), U2201.1 (~PL)
/digital_control_board/sheet63FDD82A/MISO: J2201.9 (MISO), M2201.2 (PB6); also elsewhere on the board
/digital_control_board/sheet63FDD82A/MOSI: J2201.1 (MOSI), M2201.1 (PB5); also elsewhere on the board
/digital_control_board/sheet63FDD82A/SCLK: J2201.7 (SCK), M2201.3 (PB7); also elsewhere on the board
/digital_control_board/sheet63FDD82A/X1: C2202.2, M2201.8 (XTAL1), Y2201.1
/digital_control_board/sheet63FDD82A/X2: C2203.2, M2201.7 (XTAL2), Y2201.2
/digital_control_board/sheet63FDD82A/~RST: C2204.1, J2201.5 (~RST), M2201.4 (~RESET), R2202.2
/digital_control_board/~C1_CS_ADC: M2201.24 (PC5); also elsewhere on the board
/digital_control_board/~C2_CS_ADC: M2201.26 (PC7); also elsewhere on the board
/digital_control_board/~C3_CS_ADC: M2201.42 (PB2); also elsewhere on the board
/digital_control_board/~C4_CS_ADC: M2201.44 (PB4); also elsewhere on the board
/digital_control_board/~C5_CS_ADC: M2201.20 (PC1); also elsewhere on the board
/digital_control_board/~C6_CS_ADC: M2201.22 (PC3); also elsewhere on the board
/digital_control_board/~C7_CS_ADC: M2201.16 (PD7); also elsewhere on the board
unnamed: R2201.2, R2202.1, SW2201.2
unnamed: R2203.2, U2201.10 (DS)
unnamed: R2204.2, U2201.6 (D7)
PCOM: C2201.1, C2202.1, C2203.1, C2204.2, C2205.2, C2206.1, C2207.2, C2208.2, J2201.4 (GND), J2201.6 (GND), J2201.8 (GND), J2201.10 (GND), M2201.6 (GND), M2201.18 (GND), M2201.28 (GND), M2201.39 (GND), R2203.1, R2204.1, SW2201.1, U2201.8 (GND); also elsewhere on the board
RCLK: M2201.30 (PA7); also elsewhere on the board
RXD1: M2201.9 (PD0); also elsewhere on the board
SRCLK: M2201.33 (PA4), U2201.2 (CP); also elsewhere on the board
TXD1: M2201.10 (PD1); also elsewhere on the board
~OE: M2201.32 (PA5), U2201.15 (~CE); also elsewhere on the board
~SRCLR: M2201.31 (PA6); also elsewhere on the board

Notes on the sheet:
PULLDOWN UNUSED PIN TO KEEP IT AT LOGIC LOW.
AVR 10-PIN ISP HEADER FOR AVR-ISP-MK2
ERROR SIGNAL INPUTS FROM THE CHANNEL PGA ICS

Parts:
C2101, C2105, C2107, C2109, C2114: 10uF; C_0402_1005Metric
C2102, C2106, C2108, C2110, C2111, C2113, C2115: 0.1uF; C_0402_1005Metric
C2103, C2104: 18pF; C_0402_1005Metric
C2112: 1uF; C_0402_1005Metric
FB2102: Ferrite_Bead_Small; L_0603_1608Metric
IC2101, IC2102: SN74LVC1G14DRL; SOT-553
J2101: PinHeader_2x05_P2.54mm_Vertical
J2102, J2103, J2104, J2105, J2107: Conn_01x02_MountingPin; Molex_Pico-Clasp_202396-0207_1x02-1MP_P1.00mm_Horizontal
J2106: Conn_02x10_Counter_Clockwise; Molex_Micro-Fit_3.0_43045-2012_2x10_P3.00mm_Vertical
J2108: Conn_01x03; Molex_MicroClasp_55932-0330_1x03_P2.00mm_Vertical
M2101: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
Q2101: MMBT3904LT1G; SOT-23-3; MPN MMBT3904LT1G; Digi-Key_PN MMBT3904LT1GOSCT-ND
R2101: 10k; R_0402_1005Metric
R2102: 330; R_0402_1005Metric
R2103, R2104, R2105, R2106, R2107: 1k; R_0402_1005Metric
R2108: 4k7; R_0402_1005Metric
R2109: 100k; R_0402_1005Metric
SW2101: EVQQ2; SW_SPST_EVQQ2
Y2101: TXC 20MHz; Crystal_SMD_HC49-SD

Connections:
+5V_MAINS: C2101.1, C2102.1, C2107.2, C2108.1, C2109.1, C2110.1, C2113.1, C2114.2, C2115.2, FB2102.2, IC2101.5 (VCC), IC2102.5 (VCC), J2101.2 (VCC), J2106.1, M2101.2 (UVCC), M2101.7 (VBUS), M2101.14 (VCC), M2101.24 (AVCC), M2101.34 (VCC), M2101.44 (AVCC), R2101.1, R2108.2; also elsewhere on the board
/digital_control_board/sheet61502E6C/X1: C2104.2, M2101.17 (XTAL1), Y2101.2
/digital_control_board/sheet61502E6C/X2: C2103.2, M2101.16 (XTAL2), Y2101.1
/digital_control_board/sheet61502E6C/~RST: C2111.1, J2101.5 (~RST), M2101.13 (~RESET), R2102.1
CTR: M2101.38 (PF5); also elsewhere on the board
EXT_SYNCIO: M2101.28 (PB4), Q2101.3, R2108.1
GNDPWR: J2102.MP (MountPin), J2103.MP (MountPin), J2104.MP (MountPin), J2105.MP (MountPin), J2107.MP (MountPin)
ICE_MODE: J2108.2, M2101.40 (PF1)
unnamed: C2105.1, C2106.1, FB2102.1, M2101.42 (AREF)
unnamed: C2112.1, M2101.6 (UCAP)
unnamed: C2112.2, M2101.5 (UGND)
unnamed: IC2101.2, M2101.31 (PC6)
unnamed: IC2102.4, M2101.32 (PC7)
unnamed: J2106.14, R2107.2
unnamed: J2106.15, R2106.2
unnamed: J2106.16, R2105.2
unnamed: J2106.17, R2104.2
unnamed: J2106.18, R2103.2
unnamed: J2107.1, R2109.1
unnamed: Q2101.1, R2109.2
unnamed: R2101.2, R2102.2, SW2101.1
OPEN_WATER_MODE: J2108.1, M2101.41 (PF0)
PCOM: C2101.2, C2102.2, C2103.1, C2104.1, C2105.2, C2106.2, C2107.1, C2108.2, C2109.2, C2110.2, C2111.2, C2113.2, C2114.1, C2115.1, IC2101.3 (GND), IC2102.3 (GND), J2101.4 (GND), J2101.6 (GND), J2101.8 (GND), J2101.10 (GND), J2102.2, J2103.2, J2104.2, J2105.2, J2106.10, J2106.11, J2106.12, J2106.13, J2107.2, J2108.3, M2101.15 (GND), M2101.23 (GND), M2101.35 (GND), M2101.43 (GND), Q2101.2, SW2101.2; also elsewhere on the board
PWRLVL_SEL: J2106.3, M2101.36 (PF7)
RXD0: M2101.21 (PD3); also elsewhere on the board
SYNCIO: M2101.39 (PF4); also elsewhere on the board
TXD0: M2101.20 (PD2); also elsewhere on the board
TX_ARM_SWITCH: J2103.1, M2101.26 (PD6); also elsewhere on the board
TX_MISO: J2101.9 (MISO), M2101.11 (PB3), R2105.1
TX_MOSI: J2101.1 (MOSI), M2101.10 (PB2), R2106.1
TX_OVERHEAT_TTL: IC2102.2, J2106.5
TX_RUN_SWITCH: J2104.1, M2101.22 (PD5); also elsewhere on the board
TX_SCLK: J2101.7 (SCK), M2101.9 (PB1), R2107.1
TX_TEMP_SCL: J2106.20, M2101.18 (PD0)
TX_TEMP_SDA: J2106.19, M2101.19 (PD1)
WAVE_MODE: J2106.2, M2101.37 (PF6)
~ALRT_INT: J2106.6, M2101.8 (PB0); also elsewhere on the board
~EXT_WAVE_ENABLE_SW: J2105.1, M2101.25 (PD4)
~SHDN: M2101.29 (PB5); also elsewhere on the board
~SYNC_EXT_ENABLE_SW: J2102.1, M2101.27 (PD7)
~TX_DAC_CS: M2101.33 (~HWB~/PE2), R2103.1
~TX_SHDN_EN: IC2101.4, J2106.4
~VSENSE_CS: M2101.12 (PB7), R2104.1

Notes on the sheet:
TO DISPuC
THIS IS INVERTING, SO REMEMBER THAT IN THE FIRMWARE!
BNC PANEL INPUT
OTTO CONTROLS K4
OTTO CONTROLS R2
